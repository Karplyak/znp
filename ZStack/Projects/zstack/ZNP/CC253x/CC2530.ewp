# IAR project CC2530.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\SE\Source; ..\..\ZMAIN\TI2530ZNP; ..\..\..\..\COMPONENTS\MT; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530ZNP; ..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\Tools\CC2530DB\f8w2530.xcl
configuration TestHex (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ASSERT_RESET; MT_SYS_OSAL_NV_READ_CERTIFICATE_DATA=TRUE; MT_SYS_KEY_MANAGEMENT; ZCL_KEY_ESTABLISH; TC_LINKKEY_JOIN; SECURE=1
  postbuild: "tools\znp.bat" "tools" "CC2530-TestHex"
configuration ProdSBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ASSERT_RESET; MAKE_CRC_SHDW
  postbuild: "tools\znp.bat" "tools" "CC2530-ProdSBL"
  XLINK.XclFile: ..\..\Tools\CC2530DB\cc2530-sb.xcl
configuration ProdHex (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ASSERT_RESET; FAKE_CRC_SHDW
  postbuild: "tools\znp.bat" "tools" "CC2530-ProdHex"
  XLINK.XclFile: tools\znp-prod.xcl
  group App
    ../Source/: OSAL_ZNP.c znp_app.c znp_app.h znp_spi.c znp_spi.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/hal/include/: hal_ccm.h
  group HAL/Target/CC2530ZNP/Config
    ../../../../COMPONENTS/hal/target/CC2530ZNP/: hal_board_cfg.h
  group HAL/Target/CC2530ZNP/Drivers
    ../../../../Components/hal/target/CC2530ZNP/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530ZNP/Includes
    ../../../../COMPONENTS/hal/target/CC2530ZNP/: hal_aes.h hal_mcu.h hal_types.h
    ../../../../Components/hal/target/CC2530ZNP/: hal_dma.h hal_spi.h
  group MAC/High Level
    ../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c
    ../../../../COMPONENTS/mac/HIGH_LEVEL/: mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../../Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
    ../../../../COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h
  group MT
    ../../../../Components/mt/: DebugTrace.c MT.c MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_SAPI.c MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c
    ../../../../COMPONENTS/mt/: DebugTrace.h MT.h MT_RPC.h MT_SAPI.h MT_ZDO.h
  group NWK
    ../../../../COMPONENTS/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.h
    ../../../../Components/stack/nwk/: aps_util.h nwk_globals.c stub_aps.c
    ../../../../Components/stack/sys/: ZGlobals.c
    ../../../../COMPONENTS/stack/sys/: ZGlobals.h
  group OSAL
    ../../../../COMPONENTS/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../Components/stack/af/: AF.c
    ../../../../COMPONENTS/stack/af/: AF.h
    ../../../../Components/stack/sapi/: sapi.c
    ../../../../COMPONENTS/stack/sapi/: sapi.h
    ../../../../Components/stack/zcl/: zcl.c zcl_key_establish.c zcl_key_establish.h
    ../../../../COMPONENTS/stack/zcl/: zcl.h
  group Security
    ../../../../COMPONENTS/stack/sec/: eccapi.h ssp.h ssp_hash.h
  group Services
    ../../../../Components/services/saddr/: saddr.c
    ../../../../COMPONENTS/services/saddr/: saddr.h
  group Tools
    ../../Tools/CC2530DB/: f8wConfig.cfg f8wZCL.cfg
    ../Source/: znp.cfg
  group ZDO
    ../../../../Components/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../../COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDObject.h ZDProfile.h
  group ZMac
    ../../../../Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../../COMPONENTS/zmac/: ZMAC.h
    ../../../../COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../ZMain/TI2530ZNP/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
