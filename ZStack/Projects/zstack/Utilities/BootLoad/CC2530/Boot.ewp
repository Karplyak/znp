# IAR project Boot.ewp, settings and files
configuration CC2530 Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=254
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\_COMMON\CC2530; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\sb-boot.xcl
  group App
    ../../../../../Components/osal/include/: comdef.h
    ../Source/: sb_exec.c sb_exec.h
    source/: sb_main.c sb_main.h
  group HAL/Include
    ../../../../../Components/hal/include/: hal_defs.h
    ../../../../../COMPONENTS/hal/include/: hal_flash.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_flash.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_dma.h hal_mcu.h hal_types.h
  group Tools
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot.xcl
